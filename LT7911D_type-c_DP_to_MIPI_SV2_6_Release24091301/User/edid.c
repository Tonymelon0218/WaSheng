#include "include.h"

u8 Edid[256] = {
	0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0xD4, 0x32, 0x31, 0x00, 0x88, 0x88, 0x88,
	0x20, 0x1C, 0x01, 0x03, 0x80, 0x0C, 0x07, 0x78, 0x0A, 0x0D, 0xC9, 0xA0, 0x57, 0x47, 0x98, 0x27,
	0x12, 0x48, 0x4C, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
	0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x3A, 0x80, 0x18, 0x71, 0x38, 0x2D, 0x40, 0x58, 0x2C,
	0x45, 0x00, 0x80, 0x38, 0x74, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0A,
	0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0xFC,
	0x00, 0x4C, 0x6F, 0x6E, 0x74, 0x69, 0x75, 0x6D, 0x0A, 0x20, 0x20, 0x20, 0x20, 0x20, 0x01, 0x39,

	0x02, 0x03, 0x12, 0xF1, 0x23, 0x09, 0x07, 0x07, 0x83, 0x01, 0x00, 0x00, 0x65, 0x03, 0x0C, 0x00,
	0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xB6};

void EDID_Dtb_Block_Calc(u8 *Pbuf)
{
	u16 Hblanking, Vblanking;

	Hblanking = g_TimingStr.Hfp + g_TimingStr.Hsw + g_TimingStr.Hbp;
	Vblanking = g_TimingStr.Vfp + g_TimingStr.Vsw + g_TimingStr.Vbp;

	Pbuf[0] = (g_TimingStr.PixelClock / 10) % 256;					// pix_clock low
	Pbuf[1] = (g_TimingStr.PixelClock / 10) / 256;					// pix_clock high
	Pbuf[2] = g_TimingStr.Hactive % 256;							// hact low
	Pbuf[3] = Hblanking % 256;										// H blanking low
	Pbuf[4] = ((g_TimingStr.Hactive / 256) << 4) + Hblanking / 256; // Hact : Hblank
	Pbuf[5] = g_TimingStr.Vactive % 256;							// vact low
	Pbuf[6] = Vblanking % 256;										// V blanking low
	Pbuf[7] = ((g_TimingStr.Vactive / 256) << 4) + Vblanking / 256; // Hact : Hblank
	Pbuf[8] = g_TimingStr.Hfp % 256;								// H sync offset low
	Pbuf[9] = g_TimingStr.Hsw % 256;								// H sync width low
	Pbuf[10] = ((g_TimingStr.Vfp % 16) << 4) + g_TimingStr.Vsw % 16;
	Pbuf[11] = ((g_TimingStr.Hfp / 256) << 6) + ((g_TimingStr.Hsw / 256) << 4) +
			   ((g_TimingStr.Vfp / 16) << 2) + (g_TimingStr.Vsw / 16);
	Pbuf[12] = g_TimingStr.Hactive % 256;
	Pbuf[13] = g_TimingStr.Vactive % 256;
	Pbuf[14] = ((g_TimingStr.Hactive / 256) << 4) + g_TimingStr.Vactive / 256;
	Pbuf[17] = (0x18 | (g_TimingStr.Hspol << 1)) | (g_TimingStr.Vspol << 2); // progress V+ H+
}

void EDID_CheckSum_Calc(u8 *pbuf)
{
	u8 loopx, wr_chcsum;

	wr_chcsum = 0;
	for (loopx = 0; loopx < 127; loopx++)
		wr_chcsum += pbuf[loopx];
	wr_chcsum = 0xFF - wr_chcsum + 1;
	pbuf[0x7f] = wr_chcsum;

	wr_chcsum = 0;
	for (loopx = 0; loopx < 127; loopx++)
		wr_chcsum += pbuf[loopx + 128];
	wr_chcsum = 0xFF - wr_chcsum + 1;
	pbuf[0xff] = wr_chcsum;
}
#if 0
void UpdateEdid(void)
{
	u16 i;
	u8 Block0Checksum=0;
	u8 Block1Checksum=0;
	u8 Rflash[256]={0};

	for(i=0;i<sizeof(Rflash);i++)
	{
		Rflash[i] = 0;		
	}
#if 0 // just for test
		WriteFlash(&Edid[0]);	
		ReadFlash(&Rflash[0]);
#else
		ReadFlash(&Rflash[0]);
#endif

#if 1	
	if((Rflash[0]==0x00)&&(Rflash[1]==0xFF)&&(Rflash[2]==0xFF)
		&&(Rflash[3]==0xFF)&&(Rflash[4]==0xFF)&&(Rflash[5]==0xFF)
		&&(Rflash[6]==0xFF)&&(Rflash[7]==0x00)&&(Rflash[128]==0x02)
		&&(Rflash[129]==0x03))
	{
		Block0Checksum = Rflash[127];//Block0 Checksum
		Block1Checksum = Rflash[255];//Block1 Checksum
		
		EDID_CheckSum_Calc(&Rflash[0]);//Calc Block0&1 Checksum
	if((Block0Checksum!=Rflash[127])||(Block1Checksum!=Rflash[255]))
	{	//default edid
#if 0
			printf ("\r\n Flash EDID CheckSum_Calc is Fail");
			printf ("\r\n Load Default Edid******");
#endif
		;
		
	}
	else
	{	//Read from flash edid
#if 0
			printf ("\r\n Flash EDID CheckSum_Calc is Right");
#endif

		for(i=0;i<sizeof(Rflash);i++)
		{
			Edid[i] = Rflash[i];		
		}
	}
	}
#endif	

}
#endif
